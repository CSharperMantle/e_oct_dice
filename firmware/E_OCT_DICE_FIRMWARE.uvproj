# Keil uVision project E_OCT_DICE_FIRMWARE.uvproj, settings and files
target Dev STC8H8K64U (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: E_OCT_DICE_FIRMWARE_DEV_STC8H8K64U +hex
  c flags: Optimize=9
  c define: __CX51__, __CONF_MCU_MODEL=MCU_MODEL_STC8H8K64U, __CONF_FOSC=24000000UL, MPU6500, E_OCT_DICE_DEV_STC8H8K64U
  c include: .\lib
  group main
    ./: main.c STARTUP.A51
  group lib/eml
    ./lib/eml/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group lib/fwlib
    ./lib/fwlib/: fw_i2c.c fw_uart.c
  group lib/pd_sleep
    ./lib/pd_sleep/: pd_sleep.c
target Rel STC8G1K17 (MCS-51)
  device: STC8H1K28 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x6FF8) CLOCK(35000000) MODP2
  output: E_OCT_DICE_FIRMWARE_REL_STC8G1K17 +hex
  c flags: Optimize=9
  c define: __CX51__, __CONF_MCU_MODEL=MCU_MODEL_STC8G1K17, __CONF_FOSC=24000000UL, MPU6500, E_OCT_DICE_REL_STC8G1K17
  c include: .\lib
target Rel STC8H1K28 (MCS-51)
  device: STC8H1K28 Series STC
  cpu: as above
  output: E_OCT_DICE_FIRMWARE_REL_STC8H1K28 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: __CX51__, __CONF_MCU_MODEL=MCU_MODEL_STC8H1K28, __CONF_FOSC=24000000UL, MPU6500, E_OCT_DICE_REL_STC8H1K28
  c include: .\lib
