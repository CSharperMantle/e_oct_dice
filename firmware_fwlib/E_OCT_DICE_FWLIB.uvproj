# Keil uVision project E_OCT_DICE_FWLIB.uvproj, settings and files
target Target STC8H8K64U (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: E_OCT_DICE_FWLIB +hex
  c flags: Optimize=9
  c define: __CX51__, __CONF_MCU_MODEL=MCU_MODEL_STC8H8K64U, __CONF_FOSC=24000000UL, MPU6500
  group main
    ./: main.c
  group lib/eml
    ./: inv_mpu.c
  group lib/fw_lib
    ./: fw_i2c.c fw_sys.c fw_tim.c fw_uart.c
  group lib/mahony
    ./: MahonyAHRS.c
target Target STC8G1K08 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: as above
  output: E_OCT_DICE_FWLIB
  c flags: Optimize=8 SizeSpeed=1
